# IAR project SL1523.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430ff.h
  General.OGChipSelectMenu: MSP430F247 MSP430F247
  General.GStackSize2: 500
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\source\source\sys_msp430\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F247.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group common
    ../source/common/: drv_usart.c usart.c usmart.c usmart_config.c usmart_str.c
  group iso14443
    ../source/iso14443/: iso14443_4.c iso14443a.c iso14443b.c mifare.c Rfid_interface.c sl2523.c
  group sys_msp430
    ../source/sys_msp430/: console_api.c lpcd.c main.c mcu.c
